# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_COM5)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\libraries\drivers\inc;..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\freertos\source\include;..\freertos\source\portable\rvds\ARM_CM4F;..\user\inc;..\app_task\inc;..\driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x90000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../user/: main.c at32f435_437_clock.c at32f435_437_int.c at32f435_437_board.c freertos_tick.c
    ../user/inc/: FreeRTOSConfig.h
  group driver
    ../driver/: drv_qspi.c
  group firmware
    ../libraries/drivers/src/: at32f435_437_adc.c at32f435_437_acc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_i2c.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c at32f435_437_crm.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_usart.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group freertos
    ../freertos/source/: tasks.c timers.c queue.c event_groups.c croutine.c list.c stream_buffer.c
    ../freertos/source/portable/memmang/: heap_4.c
    ../freertos/source/portable/rvds/ARM_CM4F/: port.c
