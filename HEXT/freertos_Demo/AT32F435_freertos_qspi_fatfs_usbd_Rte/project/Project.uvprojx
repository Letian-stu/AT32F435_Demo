# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARM_COM5)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: ..\libraries\cmsis\cm4\core_support;..\user\inc;..\fatfs\source;..\driver\inc;..\usbd\usb_drivers\inc;..\usbd\msc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x90000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../user/: main.c at32f435_437_clock.c at32f435_437_int.c at32f435_437_board.c msc_diskio.c
    ../user/inc/: main.h msc_diskio.h usb_conf.h
  group drv
    ../driver/: drv_qspi.c drv_usbd.c
  group fs
    ../fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c ffconf.h
  group usbd_class
    ../usbd/msc/: msc_class.c msc_desc.c msc_bot_scsi.c
  group usbd_driver
    ../usbd/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Coroutines 10.4.3, RTOS:Event Groups 10.4.3, RTOS:Heap 10.4.3, RTOS:Message Buffer 10.4.3, RTOS:Stream Buffer 10.4.3, RTOS:Timers 10.4.3, Device:Startup 2.0.0, Device:at32f435_437_conf 2.0.0, Device:at32f435_437_firmware_library:acc 2.0.0, Device:at32f435_437_firmware_library:adc 2.0.0, Device:at32f435_437_firmware_library:can 2.0.0, Device:at32f435_437_firmware_library:crc 2.0.0, Device:at32f435_437_firmware_library:crm 2.0.0, Device:at32f435_437_firmware_library:dac 2.0.0, Device:at32f435_437_firmware_library:debug 2.0.0, Device:at32f435_437_firmware_library:dma 2.0.0, Device:at32f435_437_firmware_library:dvp 2.0.0, Device:at32f435_437_firmware_library:edma 2.0.0, Device:at32f435_437_firmware_library:emac 2.0.0, Device:at32f435_437_firmware_library:ertc 2.0.0, Device:at32f435_437_firmware_library:exint 2.0.0, Device:at32f435_437_firmware_library:flash 2.0.0, Device:at32f435_437_firmware_library:gpio 2.0.0, Device:at32f435_437_firmware_library:i2c 2.0.0, Device:at32f435_437_firmware_library:misc 2.0.0, Device:at32f435_437_firmware_library:pwc 2.0.0, Device:at32f435_437_firmware_library:qspi 2.0.0, Device:at32f435_437_firmware_library:scfg 2.0.0, Device:at32f435_437_firmware_library:sdio 2.0.0, Device:at32f435_437_firmware_library:spi 2.0.0, Device:at32f435_437_firmware_library:tmr 2.0.0, Device:at32f435_437_firmware_library:usart 2.0.0, Device:at32f435_437_firmware_library:usb 2.0.0, Device:at32f435_437_firmware_library:wdt 2.0.0, Device:at32f435_437_firmware_library:wwdt 2.0.0, Device:at32f435_437_firmware_library:xmc 2.0.0
