# Keil uVision project qspi_algorithm.uvprojx, settings and files
target qspi_algorithm (5060960::V5.06 update 7 (build 960)::.\ARM_COM5)
  device: -AT32F435RGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qspi_algorithm_w25q32 +hex
  AfterMake: cmd.exe /C copy !L .\@L.FLM
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashPrg.c
  group Device Description
    ../src/: FlashDev.c
  group driver
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_pwc.c at32f435_437_qspi.c
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group readme
    ../: readme.txt
